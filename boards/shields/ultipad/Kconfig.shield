## boards/shields/ultipad/Kconfig.shield
```kconfig
# Copyright (c) 2021 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_ULTIPAD
    def_bool $(shields_list_contains,ultipad)
```
